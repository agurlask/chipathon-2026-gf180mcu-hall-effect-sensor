v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Bias/Supply} 0 -620 0 0 0.4 0.4 {}
T {Sensor Bias Current} 0 -440 0 0 0.4 0.4 {}
T {Inst. Amp Bias Current} 0 -320 0 0 0.4 0.4 {}
T {Inst. Amp Common-Mode} 0 -220 0 0 0.4 0.4 {}
C {iopin.sym} 0 -560 0 0 {name=p1 lab=iref}
C {iopin.sym} 0 -520 0 0 {name=p2 lab=vdd}
C {iopin.sym} 0 -480 0 0 {name=p3 lab=vss}
C {iopin.sym} 0 -380 0 0 {name=p17 lab=sens_ibias}
C {iopin.sym} 0 -260 0 0 {name=p4 lab=ia_ibias}
C {iopin.sym} 0 -160 0 0 {name=p5 lab=vcm}
C {title.sym} 160 -40 0 0 {name=l1 author="alang"}
