** sch_path: xschem/ccia_top_level/b9_ccia_top_level_tb_sine.sch
**.subckt b9_ccia_top_level_tb_sine
x1 vin_p net1 net2 vin_n vout_p net3 net4 vout_n net5 phi1 phi2 net6 net7 vdd net8 vss net9 vcm
+ ibias_main_ota_pres net10 net11 ibias_main_ota ibias_rrl_pres net12 net13 ibias_rrl_gm3 ibias_rrl_gm4 net14 vdd net15
+ net16 vdd vdd net17 net18 vdd vdd net19 net20 b9_ccia_top_level
C1 vout_n vss 10p m=1
C2 vout_p vss 10p m=1
* noconn #net1
* noconn #net2
* noconn #net3
* noconn #net4
* noconn #net5
* noconn #net6
* noconn #net7
* noconn #net8
* noconn #net9
* noconn #net10
* noconn #net11
* noconn #net12
* noconn #net13
* noconn #net14
* noconn #net15
* noconn #net16
* noconn #net17
* noconn #net18
* noconn #net19
* noconn #net20
I0 vdd ibias_main_ota_pres 100n
I1 vdd ibias_main_ota 10u
I2 vdd ibias_rrl_pres 100n
I3 ibias_rrl_gm4 vss 10u
I4 ibias_rrl_gm3 vss 10u
V7 vcm vss {vcm}
E1 vin_p vcm vin vss 0.5
E2 vin_n vcm vin vss -0.5
V5 vdd vss 3.3
V6 vss 0 0
V1 vin vss SIN(0 {vd} 10e3)
V2 phi1 vss PULSE(3.3 0 0 500p 500p {tper/2+tdead+500p} {tper})
V8 phi2 vss PULSE(3.3 0 {tper/2} 500p 500p {tper/2+tdead+500p} {tper})
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.include /foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice


.param vcm=1
.param vd=1m
.param tper=10u
.param tdead=1n
.control
save all
save @m.x1.x1.x10.x1.xm1.m0[id] @m.x1.x1.x10.x1.xm1.m0[gm] @m.x1.x1.x10.x1.xm1.m0[gds]
+ @m.x1.x1.x10.x1.xm1.m0[cdb] @m.x1.x1.x10.x1.xm1.m0[cgs] @m.x1.x1.x10.x1.xm1.m0[csb] @m.x1.x1.x10.x1.xm1.m0[cgd]
save @m.x1.x1.x10.x1.xm2.m0[id] @m.x1.x1.x10.x1.xm2.m0[gm] @m.x1.x1.x10.x1.xm2.m0[gds]
+ @m.x1.x1.x10.x1.xm2.m0[cdb] @m.x1.x1.x10.x1.xm2.m0[cgs] @m.x1.x1.x10.x1.xm2.m0[csb] @m.x1.x1.x10.x1.xm2.m0[cgd]
save @m.x1.x1.x10.xm1.m0[id] @m.x1.x1.x10.xm1.m0[gm] @m.x1.x1.x10.xm1.m0[gds]
+ @m.x1.x1.x10.xm1.m0[cdb] @m.x1.x1.x10.xm1.m0[cgs] @m.x1.x1.x10.xm1.m0[csb] @m.x1.x1.x10.xm1.m0[cgd]
save @m.x1.x1.x12.x1.xm1.m0[id] @m.x1.x1.x12.x1.xm1.m0[gm] @m.x1.x1.x12.x1.xm1.m0[gds]
+ @m.x1.x1.x12.x1.xm1.m0[cdb] @m.x1.x1.x12.x1.xm1.m0[cgs] @m.x1.x1.x12.x1.xm1.m0[csb] @m.x1.x1.x12.x1.xm1.m0[cgd]
save @m.x1.x1.x12.x1.xm2.m0[id] @m.x1.x1.x12.x1.xm2.m0[gm] @m.x1.x1.x12.x1.xm2.m0[gds]
+ @m.x1.x1.x12.x1.xm2.m0[cdb] @m.x1.x1.x12.x1.xm2.m0[cgs] @m.x1.x1.x12.x1.xm2.m0[csb] @m.x1.x1.x12.x1.xm2.m0[cgd]
save @m.x1.x1.x12.xm1.m0[id] @m.x1.x1.x12.xm1.m0[gm] @m.x1.x1.x12.xm1.m0[gds]
+ @m.x1.x1.x12.xm1.m0[cdb] @m.x1.x1.x12.xm1.m0[cgs] @m.x1.x1.x12.xm1.m0[csb] @m.x1.x1.x12.xm1.m0[cgd]
save @m.x1.x1.x15.m0[id] @m.x1.x1.x15.m0[gm] @m.x1.x1.x15.m0[gds] @m.x1.x1.x15.m0[cdb]
+ @m.x1.x1.x15.m0[cgs] @m.x1.x1.x15.m0[csb] @m.x1.x1.x15.m0[cgd]
save @m.x1.x1.x13.x1.xm1.m0[id] @m.x1.x1.x13.x1.xm1.m0[gm] @m.x1.x1.x13.x1.xm1.m0[gds]
+ @m.x1.x1.x13.x1.xm1.m0[cdb] @m.x1.x1.x13.x1.xm1.m0[cgs] @m.x1.x1.x13.x1.xm1.m0[csb] @m.x1.x1.x13.x1.xm1.m0[cgd]
save @m.x1.x1.x13.x1.xm2.m0[id] @m.x1.x1.x13.x1.xm2.m0[gm] @m.x1.x1.x13.x1.xm2.m0[gds]
+ @m.x1.x1.x13.x1.xm2.m0[cdb] @m.x1.x1.x13.x1.xm2.m0[cgs] @m.x1.x1.x13.x1.xm2.m0[csb] @m.x1.x1.x13.x1.xm2.m0[cgd]
save @m.x1.x1.x13.xm1.m0[id] @m.x1.x1.x13.xm1.m0[gm] @m.x1.x1.x13.xm1.m0[gds]
+ @m.x1.x1.x13.xm1.m0[cdb] @m.x1.x1.x13.xm1.m0[cgs] @m.x1.x1.x13.xm1.m0[csb] @m.x1.x1.x13.xm1.m0[cgd]
save @m.x1.x1.x14.x1.xm1.m0[id] @m.x1.x1.x14.x1.xm1.m0[gm] @m.x1.x1.x14.x1.xm1.m0[gds]
+ @m.x1.x1.x14.x1.xm1.m0[cdb] @m.x1.x1.x14.x1.xm1.m0[cgs] @m.x1.x1.x14.x1.xm1.m0[csb] @m.x1.x1.x14.x1.xm1.m0[cgd]
save @m.x1.x1.x14.x1.xm2.m0[id] @m.x1.x1.x14.x1.xm2.m0[gm] @m.x1.x1.x14.x1.xm2.m0[gds]
+ @m.x1.x1.x14.x1.xm2.m0[cdb] @m.x1.x1.x14.x1.xm2.m0[cgs] @m.x1.x1.x14.x1.xm2.m0[csb] @m.x1.x1.x14.x1.xm2.m0[cgd]
save @m.x1.x1.x14.xm1.m0[id] @m.x1.x1.x14.xm1.m0[gm] @m.x1.x1.x14.xm1.m0[gds]
+ @m.x1.x1.x14.xm1.m0[cdb] @m.x1.x1.x14.xm1.m0[cgs] @m.x1.x1.x14.xm1.m0[csb] @m.x1.x1.x14.xm1.m0[cgd]
save @m.x1.x1.x16.x1.xm1.m0[id] @m.x1.x1.x16.x1.xm1.m0[gm] @m.x1.x1.x16.x1.xm1.m0[gds]
+ @m.x1.x1.x16.x1.xm1.m0[cdb] @m.x1.x1.x16.x1.xm1.m0[cgs] @m.x1.x1.x16.x1.xm1.m0[csb] @m.x1.x1.x16.x1.xm1.m0[cgd]
save @m.x1.x1.x16.x1.xm2.m0[id] @m.x1.x1.x16.x1.xm2.m0[gm] @m.x1.x1.x16.x1.xm2.m0[gds]
+ @m.x1.x1.x16.x1.xm2.m0[cdb] @m.x1.x1.x16.x1.xm2.m0[cgs] @m.x1.x1.x16.x1.xm2.m0[csb] @m.x1.x1.x16.x1.xm2.m0[cgd]
save @m.x1.x1.x16.xm1.m0[id] @m.x1.x1.x16.xm1.m0[gm] @m.x1.x1.x16.xm1.m0[gds]
+ @m.x1.x1.x16.xm1.m0[cdb] @m.x1.x1.x16.xm1.m0[cgs] @m.x1.x1.x16.xm1.m0[csb] @m.x1.x1.x16.xm1.m0[cgd]
save @m.x1.x1.x17.x1.xm1.m0[id] @m.x1.x1.x17.x1.xm1.m0[gm] @m.x1.x1.x17.x1.xm1.m0[gds]
+ @m.x1.x1.x17.x1.xm1.m0[cdb] @m.x1.x1.x17.x1.xm1.m0[cgs] @m.x1.x1.x17.x1.xm1.m0[csb] @m.x1.x1.x17.x1.xm1.m0[cgd]
save @m.x1.x1.x17.x1.xm2.m0[id] @m.x1.x1.x17.x1.xm2.m0[gm] @m.x1.x1.x17.x1.xm2.m0[gds]
+ @m.x1.x1.x17.x1.xm2.m0[cdb] @m.x1.x1.x17.x1.xm2.m0[cgs] @m.x1.x1.x17.x1.xm2.m0[csb] @m.x1.x1.x17.x1.xm2.m0[cgd]
save @m.x1.x1.x17.xm1.m0[id] @m.x1.x1.x17.xm1.m0[gm] @m.x1.x1.x17.xm1.m0[gds]
+ @m.x1.x1.x17.xm1.m0[cdb] @m.x1.x1.x17.xm1.m0[cgs] @m.x1.x1.x17.xm1.m0[csb] @m.x1.x1.x17.xm1.m0[cgd]
save @m.x1.x1.x18.x1.xm1.m0[id] @m.x1.x1.x18.x1.xm1.m0[gm] @m.x1.x1.x18.x1.xm1.m0[gds]
+ @m.x1.x1.x18.x1.xm1.m0[cdb] @m.x1.x1.x18.x1.xm1.m0[cgs] @m.x1.x1.x18.x1.xm1.m0[csb] @m.x1.x1.x18.x1.xm1.m0[cgd]
save @m.x1.x1.x18.x1.xm2.m0[id] @m.x1.x1.x18.x1.xm2.m0[gm] @m.x1.x1.x18.x1.xm2.m0[gds]
+ @m.x1.x1.x18.x1.xm2.m0[cdb] @m.x1.x1.x18.x1.xm2.m0[cgs] @m.x1.x1.x18.x1.xm2.m0[csb] @m.x1.x1.x18.x1.xm2.m0[cgd]
save @m.x1.x1.x18.xm1.m0[id] @m.x1.x1.x18.xm1.m0[gm] @m.x1.x1.x18.xm1.m0[gds]
+ @m.x1.x1.x18.xm1.m0[cdb] @m.x1.x1.x18.xm1.m0[cgs] @m.x1.x1.x18.xm1.m0[csb] @m.x1.x1.x18.xm1.m0[cgd]
save @m.x1.x1.x19.x1.xm1.m0[id] @m.x1.x1.x19.x1.xm1.m0[gm] @m.x1.x1.x19.x1.xm1.m0[gds]
+ @m.x1.x1.x19.x1.xm1.m0[cdb] @m.x1.x1.x19.x1.xm1.m0[cgs] @m.x1.x1.x19.x1.xm1.m0[csb] @m.x1.x1.x19.x1.xm1.m0[cgd]
save @m.x1.x1.x19.x1.xm2.m0[id] @m.x1.x1.x19.x1.xm2.m0[gm] @m.x1.x1.x19.x1.xm2.m0[gds]
+ @m.x1.x1.x19.x1.xm2.m0[cdb] @m.x1.x1.x19.x1.xm2.m0[cgs] @m.x1.x1.x19.x1.xm2.m0[csb] @m.x1.x1.x19.x1.xm2.m0[cgd]
save @m.x1.x1.x19.xm1.m0[id] @m.x1.x1.x19.xm1.m0[gm] @m.x1.x1.x19.xm1.m0[gds]
+ @m.x1.x1.x19.xm1.m0[cdb] @m.x1.x1.x19.xm1.m0[cgs] @m.x1.x1.x19.xm1.m0[csb] @m.x1.x1.x19.xm1.m0[cgd]
save @m.x1.x1.x2.xm1.m0[id] @m.x1.x1.x2.xm1.m0[gm] @m.x1.x1.x2.xm1.m0[gds] @m.x1.x1.x2.xm1.m0[cdb]
+ @m.x1.x1.x2.xm1.m0[cgs] @m.x1.x1.x2.xm1.m0[csb] @m.x1.x1.x2.xm1.m0[cgd]
save @m.x1.x1.x2.xm7.m0[id] @m.x1.x1.x2.xm7.m0[gm] @m.x1.x1.x2.xm7.m0[gds] @m.x1.x1.x2.xm7.m0[cdb]
+ @m.x1.x1.x2.xm7.m0[cgs] @m.x1.x1.x2.xm7.m0[csb] @m.x1.x1.x2.xm7.m0[cgd]
save @m.x1.x1.x2.xm17.m0[id] @m.x1.x1.x2.xm17.m0[gm] @m.x1.x1.x2.xm17.m0[gds]
+ @m.x1.x1.x2.xm17.m0[cdb] @m.x1.x1.x2.xm17.m0[cgs] @m.x1.x1.x2.xm17.m0[csb] @m.x1.x1.x2.xm17.m0[cgd]
save @m.x1.x1.x2.xm18.m0[id] @m.x1.x1.x2.xm18.m0[gm] @m.x1.x1.x2.xm18.m0[gds]
+ @m.x1.x1.x2.xm18.m0[cdb] @m.x1.x1.x2.xm18.m0[cgs] @m.x1.x1.x2.xm18.m0[csb] @m.x1.x1.x2.xm18.m0[cgd]
save @m.x1.x1.x2.xm4.m0[id] @m.x1.x1.x2.xm4.m0[gm] @m.x1.x1.x2.xm4.m0[gds] @m.x1.x1.x2.xm4.m0[cdb]
+ @m.x1.x1.x2.xm4.m0[cgs] @m.x1.x1.x2.xm4.m0[csb] @m.x1.x1.x2.xm4.m0[cgd]
save @m.x1.x1.x2.xm16.m0[id] @m.x1.x1.x2.xm16.m0[gm] @m.x1.x1.x2.xm16.m0[gds]
+ @m.x1.x1.x2.xm16.m0[cdb] @m.x1.x1.x2.xm16.m0[cgs] @m.x1.x1.x2.xm16.m0[csb] @m.x1.x1.x2.xm16.m0[cgd]
save @m.x1.x1.x2.xm19.m0[id] @m.x1.x1.x2.xm19.m0[gm] @m.x1.x1.x2.xm19.m0[gds]
+ @m.x1.x1.x2.xm19.m0[cdb] @m.x1.x1.x2.xm19.m0[cgs] @m.x1.x1.x2.xm19.m0[csb] @m.x1.x1.x2.xm19.m0[cgd]
save @m.x1.x1.x2.xm11.m0[id] @m.x1.x1.x2.xm11.m0[gm] @m.x1.x1.x2.xm11.m0[gds]
+ @m.x1.x1.x2.xm11.m0[cdb] @m.x1.x1.x2.xm11.m0[cgs] @m.x1.x1.x2.xm11.m0[csb] @m.x1.x1.x2.xm11.m0[cgd]
save @m.x1.x1.x2.xm6.m0[id] @m.x1.x1.x2.xm6.m0[gm] @m.x1.x1.x2.xm6.m0[gds] @m.x1.x1.x2.xm6.m0[cdb]
+ @m.x1.x1.x2.xm6.m0[cgs] @m.x1.x1.x2.xm6.m0[csb] @m.x1.x1.x2.xm6.m0[cgd]
save @m.x1.x1.x2.xm25.m0[id] @m.x1.x1.x2.xm25.m0[gm] @m.x1.x1.x2.xm25.m0[gds]
+ @m.x1.x1.x2.xm25.m0[cdb] @m.x1.x1.x2.xm25.m0[cgs] @m.x1.x1.x2.xm25.m0[csb] @m.x1.x1.x2.xm25.m0[cgd]
save @m.x1.x1.x2.xm26.m0[id] @m.x1.x1.x2.xm26.m0[gm] @m.x1.x1.x2.xm26.m0[gds]
+ @m.x1.x1.x2.xm26.m0[cdb] @m.x1.x1.x2.xm26.m0[cgs] @m.x1.x1.x2.xm26.m0[csb] @m.x1.x1.x2.xm26.m0[cgd]
save @m.x1.x1.x2.xm27.m0[id] @m.x1.x1.x2.xm27.m0[gm] @m.x1.x1.x2.xm27.m0[gds]
+ @m.x1.x1.x2.xm27.m0[cdb] @m.x1.x1.x2.xm27.m0[cgs] @m.x1.x1.x2.xm27.m0[csb] @m.x1.x1.x2.xm27.m0[cgd]
save @m.x1.x1.x5.xm1.m0[id] @m.x1.x1.x5.xm1.m0[gm] @m.x1.x1.x5.xm1.m0[gds] @m.x1.x1.x5.xm1.m0[cdb]
+ @m.x1.x1.x5.xm1.m0[cgs] @m.x1.x1.x5.xm1.m0[csb] @m.x1.x1.x5.xm1.m0[cgd]
save @m.x1.x1.x5.xm2.m0[id] @m.x1.x1.x5.xm2.m0[gm] @m.x1.x1.x5.xm2.m0[gds] @m.x1.x1.x5.xm2.m0[cdb]
+ @m.x1.x1.x5.xm2.m0[cgs] @m.x1.x1.x5.xm2.m0[csb] @m.x1.x1.x5.xm2.m0[cgd]
save @m.x1.x1.x1.xm2.m0[id] @m.x1.x1.x1.xm2.m0[gm] @m.x1.x1.x1.xm2.m0[gds] @m.x1.x1.x1.xm2.m0[cdb]
+ @m.x1.x1.x1.xm2.m0[cgs] @m.x1.x1.x1.xm2.m0[csb] @m.x1.x1.x1.xm2.m0[cgd]
save @m.x1.x1.x1.xm1.m0[id] @m.x1.x1.x1.xm1.m0[gm] @m.x1.x1.x1.xm1.m0[gds] @m.x1.x1.x1.xm1.m0[cdb]
+ @m.x1.x1.x1.xm1.m0[cgs] @m.x1.x1.x1.xm1.m0[csb] @m.x1.x1.x1.xm1.m0[cgd]
save @m.x1.x1.x4.xm9.m0[id] @m.x1.x1.x4.xm9.m0[gm] @m.x1.x1.x4.xm9.m0[gds] @m.x1.x1.x4.xm9.m0[cdb]
+ @m.x1.x1.x4.xm9.m0[cgs] @m.x1.x1.x4.xm9.m0[csb] @m.x1.x1.x4.xm9.m0[cgd]
save @m.x1.x1.x4.xm22.m0[id] @m.x1.x1.x4.xm22.m0[gm] @m.x1.x1.x4.xm22.m0[gds]
+ @m.x1.x1.x4.xm22.m0[cdb] @m.x1.x1.x4.xm22.m0[cgs] @m.x1.x1.x4.xm22.m0[csb] @m.x1.x1.x4.xm22.m0[cgd]
save @m.x1.x1.x4.xm21.m0[id] @m.x1.x1.x4.xm21.m0[gm] @m.x1.x1.x4.xm21.m0[gds]
+ @m.x1.x1.x4.xm21.m0[cdb] @m.x1.x1.x4.xm21.m0[cgs] @m.x1.x1.x4.xm21.m0[csb] @m.x1.x1.x4.xm21.m0[cgd]
save @m.x1.x1.x4.xm8.m0[id] @m.x1.x1.x4.xm8.m0[gm] @m.x1.x1.x4.xm8.m0[gds] @m.x1.x1.x4.xm8.m0[cdb]
+ @m.x1.x1.x4.xm8.m0[cgs] @m.x1.x1.x4.xm8.m0[csb] @m.x1.x1.x4.xm8.m0[cgd]
save @m.x1.x1.x4.xm20.m0[id] @m.x1.x1.x4.xm20.m0[gm] @m.x1.x1.x4.xm20.m0[gds]
+ @m.x1.x1.x4.xm20.m0[cdb] @m.x1.x1.x4.xm20.m0[cgs] @m.x1.x1.x4.xm20.m0[csb] @m.x1.x1.x4.xm20.m0[cgd]
save @m.x1.x1.x3.xm14.m0[id] @m.x1.x1.x3.xm14.m0[gm] @m.x1.x1.x3.xm14.m0[gds]
+ @m.x1.x1.x3.xm14.m0[cdb] @m.x1.x1.x3.xm14.m0[cgs] @m.x1.x1.x3.xm14.m0[csb] @m.x1.x1.x3.xm14.m0[cgd]
save @m.x1.x1.x3.xm15.m0[id] @m.x1.x1.x3.xm15.m0[gm] @m.x1.x1.x3.xm15.m0[gds]
+ @m.x1.x1.x3.xm15.m0[cdb] @m.x1.x1.x3.xm15.m0[cgs] @m.x1.x1.x3.xm15.m0[csb] @m.x1.x1.x3.xm15.m0[cgd]
save @m.x1.x1.x3.xm10.m0[id] @m.x1.x1.x3.xm10.m0[gm] @m.x1.x1.x3.xm10.m0[gds]
+ @m.x1.x1.x3.xm10.m0[cdb] @m.x1.x1.x3.xm10.m0[cgs] @m.x1.x1.x3.xm10.m0[csb] @m.x1.x1.x3.xm10.m0[cgd]
save @m.x1.x1.x3.xm5.m0[id] @m.x1.x1.x3.xm5.m0[gm] @m.x1.x1.x3.xm5.m0[gds] @m.x1.x1.x3.xm5.m0[cdb]
+ @m.x1.x1.x3.xm5.m0[cgs] @m.x1.x1.x3.xm5.m0[csb] @m.x1.x1.x3.xm5.m0[cgd]
save @m.x1.x1.x3.xm23.m0[id] @m.x1.x1.x3.xm23.m0[gm] @m.x1.x1.x3.xm23.m0[gds]
+ @m.x1.x1.x3.xm23.m0[cdb] @m.x1.x1.x3.xm23.m0[cgs] @m.x1.x1.x3.xm23.m0[csb] @m.x1.x1.x3.xm23.m0[cgd]
save @m.x1.x1.x3.xm24.m0[id] @m.x1.x1.x3.xm24.m0[gm] @m.x1.x1.x3.xm24.m0[gds]
+ @m.x1.x1.x3.xm24.m0[cdb] @m.x1.x1.x3.xm24.m0[cgs] @m.x1.x1.x3.xm24.m0[csb] @m.x1.x1.x3.xm24.m0[cgd]
save @m.x1.x1.x7.xm6.m0[id] @m.x1.x1.x7.xm6.m0[gm] @m.x1.x1.x7.xm6.m0[gds] @m.x1.x1.x7.xm6.m0[cdb]
+ @m.x1.x1.x7.xm6.m0[cgs] @m.x1.x1.x7.xm6.m0[csb] @m.x1.x1.x7.xm6.m0[cgd]
save @m.x1.x1.x7.xm1.m0[id] @m.x1.x1.x7.xm1.m0[gm] @m.x1.x1.x7.xm1.m0[gds] @m.x1.x1.x7.xm1.m0[cdb]
+ @m.x1.x1.x7.xm1.m0[cgs] @m.x1.x1.x7.xm1.m0[csb] @m.x1.x1.x7.xm1.m0[cgd]
save @m.x1.x1.x7.xc1.m0[id] @m.x1.x1.x7.xc1.m0[gm] @m.x1.x1.x7.xc1.m0[gds] @m.x1.x1.x7.xc1.m0[cdb]
+ @m.x1.x1.x7.xc1.m0[cgs] @m.x1.x1.x7.xc1.m0[csb] @m.x1.x1.x7.xc1.m0[cgd]
save @m.x1.x1.x8.xm6.m0[id] @m.x1.x1.x8.xm6.m0[gm] @m.x1.x1.x8.xm6.m0[gds] @m.x1.x1.x8.xm6.m0[cdb]
+ @m.x1.x1.x8.xm6.m0[cgs] @m.x1.x1.x8.xm6.m0[csb] @m.x1.x1.x8.xm6.m0[cgd]
save @m.x1.x1.x8.xm1.m0[id] @m.x1.x1.x8.xm1.m0[gm] @m.x1.x1.x8.xm1.m0[gds] @m.x1.x1.x8.xm1.m0[cdb]
+ @m.x1.x1.x8.xm1.m0[cgs] @m.x1.x1.x8.xm1.m0[csb] @m.x1.x1.x8.xm1.m0[cgd]
save @m.x1.x1.x8.xc1.m0[id] @m.x1.x1.x8.xc1.m0[gm] @m.x1.x1.x8.xc1.m0[gds] @m.x1.x1.x8.xc1.m0[cdb]
+ @m.x1.x1.x8.xc1.m0[cgs] @m.x1.x1.x8.xc1.m0[csb] @m.x1.x1.x8.xc1.m0[cgd]
save @m.x1.x1.x6.xm15.m0[id] @m.x1.x1.x6.xm15.m0[gm] @m.x1.x1.x6.xm15.m0[gds]
+ @m.x1.x1.x6.xm15.m0[cdb] @m.x1.x1.x6.xm15.m0[cgs] @m.x1.x1.x6.xm15.m0[csb] @m.x1.x1.x6.xm15.m0[cgd]
save @m.x1.x1.x6.xm1.m0[id] @m.x1.x1.x6.xm1.m0[gm] @m.x1.x1.x6.xm1.m0[gds] @m.x1.x1.x6.xm1.m0[cdb]
+ @m.x1.x1.x6.xm1.m0[cgs] @m.x1.x1.x6.xm1.m0[csb] @m.x1.x1.x6.xm1.m0[cgd]
save @m.x1.x1.x6.xm2.m0[id] @m.x1.x1.x6.xm2.m0[gm] @m.x1.x1.x6.xm2.m0[gds] @m.x1.x1.x6.xm2.m0[cdb]
+ @m.x1.x1.x6.xm2.m0[cgs] @m.x1.x1.x6.xm2.m0[csb] @m.x1.x1.x6.xm2.m0[cgd]
save @m.x1.x1.x6.xm7.m0[id] @m.x1.x1.x6.xm7.m0[gm] @m.x1.x1.x6.xm7.m0[gds] @m.x1.x1.x6.xm7.m0[cdb]
+ @m.x1.x1.x6.xm7.m0[cgs] @m.x1.x1.x6.xm7.m0[csb] @m.x1.x1.x6.xm7.m0[cgd]
save @m.x1.x1.x6.xm8.m0[id] @m.x1.x1.x6.xm8.m0[gm] @m.x1.x1.x6.xm8.m0[gds] @m.x1.x1.x6.xm8.m0[cdb]
+ @m.x1.x1.x6.xm8.m0[cgs] @m.x1.x1.x6.xm8.m0[csb] @m.x1.x1.x6.xm8.m0[cgd]
save @m.x1.x1.x6.xm4.m0[id] @m.x1.x1.x6.xm4.m0[gm] @m.x1.x1.x6.xm4.m0[gds] @m.x1.x1.x6.xm4.m0[cdb]
+ @m.x1.x1.x6.xm4.m0[cgs] @m.x1.x1.x6.xm4.m0[csb] @m.x1.x1.x6.xm4.m0[cgd]
save @m.x1.x1.x6.xm3.m0[id] @m.x1.x1.x6.xm3.m0[gm] @m.x1.x1.x6.xm3.m0[gds] @m.x1.x1.x6.xm3.m0[cdb]
+ @m.x1.x1.x6.xm3.m0[cgs] @m.x1.x1.x6.xm3.m0[csb] @m.x1.x1.x6.xm3.m0[cgd]
save @m.x1.x1.x6.xm5.m0[id] @m.x1.x1.x6.xm5.m0[gm] @m.x1.x1.x6.xm5.m0[gds] @m.x1.x1.x6.xm5.m0[cdb]
+ @m.x1.x1.x6.xm5.m0[cgs] @m.x1.x1.x6.xm5.m0[csb] @m.x1.x1.x6.xm5.m0[cgd]
save @m.x1.x1.x6.xm6.m0[id] @m.x1.x1.x6.xm6.m0[gm] @m.x1.x1.x6.xm6.m0[gds] @m.x1.x1.x6.xm6.m0[cdb]
+ @m.x1.x1.x6.xm6.m0[cgs] @m.x1.x1.x6.xm6.m0[csb] @m.x1.x1.x6.xm6.m0[cgd]
save @m.x1.x2.x1.x1.xm2.m0[id] @m.x1.x2.x1.x1.xm2.m0[gm] @m.x1.x2.x1.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x1.xm2.m0[cdb] @m.x1.x2.x1.x1.xm2.m0[cgs] @m.x1.x2.x1.x1.xm2.m0[csb] @m.x1.x2.x1.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x1.xm3.m0[id] @m.x1.x2.x1.x1.xm3.m0[gm] @m.x1.x2.x1.x1.xm3.m0[gds]
+ @m.x1.x2.x1.x1.xm3.m0[cdb] @m.x1.x2.x1.x1.xm3.m0[cgs] @m.x1.x2.x1.x1.xm3.m0[csb] @m.x1.x2.x1.x1.xm3.m0[cgd]
save @m.x1.x2.x1.x4.xm4.m0[id] @m.x1.x2.x1.x4.xm4.m0[gm] @m.x1.x2.x1.x4.xm4.m0[gds]
+ @m.x1.x2.x1.x4.xm4.m0[cdb] @m.x1.x2.x1.x4.xm4.m0[cgs] @m.x1.x2.x1.x4.xm4.m0[csb] @m.x1.x2.x1.x4.xm4.m0[cgd]
save @m.x1.x2.x1.x4.xm16.m0[id] @m.x1.x2.x1.x4.xm16.m0[gm] @m.x1.x2.x1.x4.xm16.m0[gds]
+ @m.x1.x2.x1.x4.xm16.m0[cdb] @m.x1.x2.x1.x4.xm16.m0[cgs] @m.x1.x2.x1.x4.xm16.m0[csb] @m.x1.x2.x1.x4.xm16.m0[cgd]
save @m.x1.x2.x1.x4.xm17.m0[id] @m.x1.x2.x1.x4.xm17.m0[gm] @m.x1.x2.x1.x4.xm17.m0[gds]
+ @m.x1.x2.x1.x4.xm17.m0[cdb] @m.x1.x2.x1.x4.xm17.m0[cgs] @m.x1.x2.x1.x4.xm17.m0[csb] @m.x1.x2.x1.x4.xm17.m0[cgd]
save @m.x1.x2.x1.x4.xm18.m0[id] @m.x1.x2.x1.x4.xm18.m0[gm] @m.x1.x2.x1.x4.xm18.m0[gds]
+ @m.x1.x2.x1.x4.xm18.m0[cdb] @m.x1.x2.x1.x4.xm18.m0[cgs] @m.x1.x2.x1.x4.xm18.m0[csb] @m.x1.x2.x1.x4.xm18.m0[cgd]
save @m.x1.x2.x1.x2.xm10.m0[id] @m.x1.x2.x1.x2.xm10.m0[gm] @m.x1.x2.x1.x2.xm10.m0[gds]
+ @m.x1.x2.x1.x2.xm10.m0[cdb] @m.x1.x2.x1.x2.xm10.m0[cgs] @m.x1.x2.x1.x2.xm10.m0[csb] @m.x1.x2.x1.x2.xm10.m0[cgd]
save @m.x1.x2.x1.x2.xm11.m0[id] @m.x1.x2.x1.x2.xm11.m0[gm] @m.x1.x2.x1.x2.xm11.m0[gds]
+ @m.x1.x2.x1.x2.xm11.m0[cdb] @m.x1.x2.x1.x2.xm11.m0[cgs] @m.x1.x2.x1.x2.xm11.m0[csb] @m.x1.x2.x1.x2.xm11.m0[cgd]
save @m.x1.x2.x1.x2.xm7.m0[id] @m.x1.x2.x1.x2.xm7.m0[gm] @m.x1.x2.x1.x2.xm7.m0[gds]
+ @m.x1.x2.x1.x2.xm7.m0[cdb] @m.x1.x2.x1.x2.xm7.m0[cgs] @m.x1.x2.x1.x2.xm7.m0[csb] @m.x1.x2.x1.x2.xm7.m0[cgd]
save @m.x1.x2.x1.x2.xm8.m0[id] @m.x1.x2.x1.x2.xm8.m0[gm] @m.x1.x2.x1.x2.xm8.m0[gds]
+ @m.x1.x2.x1.x2.xm8.m0[cdb] @m.x1.x2.x1.x2.xm8.m0[cgs] @m.x1.x2.x1.x2.xm8.m0[csb] @m.x1.x2.x1.x2.xm8.m0[cgd]
save @m.x1.x2.x1.x5.xm12.m0[id] @m.x1.x2.x1.x5.xm12.m0[gm] @m.x1.x2.x1.x5.xm12.m0[gds]
+ @m.x1.x2.x1.x5.xm12.m0[cdb] @m.x1.x2.x1.x5.xm12.m0[cgs] @m.x1.x2.x1.x5.xm12.m0[csb] @m.x1.x2.x1.x5.xm12.m0[cgd]
save @m.x1.x2.x1.x5.xm13.m0[id] @m.x1.x2.x1.x5.xm13.m0[gm] @m.x1.x2.x1.x5.xm13.m0[gds]
+ @m.x1.x2.x1.x5.xm13.m0[cdb] @m.x1.x2.x1.x5.xm13.m0[cgs] @m.x1.x2.x1.x5.xm13.m0[csb] @m.x1.x2.x1.x5.xm13.m0[cgd]
save @m.x1.x2.x1.x5.xm19.m0[id] @m.x1.x2.x1.x5.xm19.m0[gm] @m.x1.x2.x1.x5.xm19.m0[gds]
+ @m.x1.x2.x1.x5.xm19.m0[cdb] @m.x1.x2.x1.x5.xm19.m0[cgs] @m.x1.x2.x1.x5.xm19.m0[csb] @m.x1.x2.x1.x5.xm19.m0[cgd]
save @m.x1.x2.x1.x5.xm22.m0[id] @m.x1.x2.x1.x5.xm22.m0[gm] @m.x1.x2.x1.x5.xm22.m0[gds]
+ @m.x1.x2.x1.x5.xm22.m0[cdb] @m.x1.x2.x1.x5.xm22.m0[cgs] @m.x1.x2.x1.x5.xm22.m0[csb] @m.x1.x2.x1.x5.xm22.m0[cgd]
save @m.x1.x2.x1.x5.xm25.m0[id] @m.x1.x2.x1.x5.xm25.m0[gm] @m.x1.x2.x1.x5.xm25.m0[gds]
+ @m.x1.x2.x1.x5.xm25.m0[cdb] @m.x1.x2.x1.x5.xm25.m0[cgs] @m.x1.x2.x1.x5.xm25.m0[csb] @m.x1.x2.x1.x5.xm25.m0[cgd]
save @m.x1.x2.x1.x5.xm26.m0[id] @m.x1.x2.x1.x5.xm26.m0[gm] @m.x1.x2.x1.x5.xm26.m0[gds]
+ @m.x1.x2.x1.x5.xm26.m0[cdb] @m.x1.x2.x1.x5.xm26.m0[cgs] @m.x1.x2.x1.x5.xm26.m0[csb] @m.x1.x2.x1.x5.xm26.m0[cgd]
save @m.x1.x2.x1.x5.xm27.m0[id] @m.x1.x2.x1.x5.xm27.m0[gm] @m.x1.x2.x1.x5.xm27.m0[gds]
+ @m.x1.x2.x1.x5.xm27.m0[cdb] @m.x1.x2.x1.x5.xm27.m0[cgs] @m.x1.x2.x1.x5.xm27.m0[csb] @m.x1.x2.x1.x5.xm27.m0[cgd]
save @m.x1.x2.x1.x5.xm28.m0[id] @m.x1.x2.x1.x5.xm28.m0[gm] @m.x1.x2.x1.x5.xm28.m0[gds]
+ @m.x1.x2.x1.x5.xm28.m0[cdb] @m.x1.x2.x1.x5.xm28.m0[cgs] @m.x1.x2.x1.x5.xm28.m0[csb] @m.x1.x2.x1.x5.xm28.m0[cgd]
save @m.x1.x2.x1.x5.xm20.m0[id] @m.x1.x2.x1.x5.xm20.m0[gm] @m.x1.x2.x1.x5.xm20.m0[gds]
+ @m.x1.x2.x1.x5.xm20.m0[cdb] @m.x1.x2.x1.x5.xm20.m0[cgs] @m.x1.x2.x1.x5.xm20.m0[csb] @m.x1.x2.x1.x5.xm20.m0[cgd]
save @m.x1.x2.x1.x5.xm21.m0[id] @m.x1.x2.x1.x5.xm21.m0[gm] @m.x1.x2.x1.x5.xm21.m0[gds]
+ @m.x1.x2.x1.x5.xm21.m0[cdb] @m.x1.x2.x1.x5.xm21.m0[cgs] @m.x1.x2.x1.x5.xm21.m0[csb] @m.x1.x2.x1.x5.xm21.m0[cgd]
save @m.x1.x2.x1.x5.xm23.m0[id] @m.x1.x2.x1.x5.xm23.m0[gm] @m.x1.x2.x1.x5.xm23.m0[gds]
+ @m.x1.x2.x1.x5.xm23.m0[cdb] @m.x1.x2.x1.x5.xm23.m0[cgs] @m.x1.x2.x1.x5.xm23.m0[csb] @m.x1.x2.x1.x5.xm23.m0[cgd]
save @m.x1.x2.x1.x3.xm1.m0[id] @m.x1.x2.x1.x3.xm1.m0[gm] @m.x1.x2.x1.x3.xm1.m0[gds]
+ @m.x1.x2.x1.x3.xm1.m0[cdb] @m.x1.x2.x1.x3.xm1.m0[cgs] @m.x1.x2.x1.x3.xm1.m0[csb] @m.x1.x2.x1.x3.xm1.m0[cgd]
save @m.x1.x2.x1.x3.xm5.m0[id] @m.x1.x2.x1.x3.xm5.m0[gm] @m.x1.x2.x1.x3.xm5.m0[gds]
+ @m.x1.x2.x1.x3.xm5.m0[cdb] @m.x1.x2.x1.x3.xm5.m0[cgs] @m.x1.x2.x1.x3.xm5.m0[csb] @m.x1.x2.x1.x3.xm5.m0[cgd]
save @m.x1.x2.x1.x3.xm15.m0[id] @m.x1.x2.x1.x3.xm15.m0[gm] @m.x1.x2.x1.x3.xm15.m0[gds]
+ @m.x1.x2.x1.x3.xm15.m0[cdb] @m.x1.x2.x1.x3.xm15.m0[cgs] @m.x1.x2.x1.x3.xm15.m0[csb] @m.x1.x2.x1.x3.xm15.m0[cgd]
save @m.x1.x2.x1.x3.xm9.m0[id] @m.x1.x2.x1.x3.xm9.m0[gm] @m.x1.x2.x1.x3.xm9.m0[gds]
+ @m.x1.x2.x1.x3.xm9.m0[cdb] @m.x1.x2.x1.x3.xm9.m0[cgs] @m.x1.x2.x1.x3.xm9.m0[csb] @m.x1.x2.x1.x3.xm9.m0[cgd]
save @m.x1.x2.x1.x3.xm6.m0[id] @m.x1.x2.x1.x3.xm6.m0[gm] @m.x1.x2.x1.x3.xm6.m0[gds]
+ @m.x1.x2.x1.x3.xm6.m0[cdb] @m.x1.x2.x1.x3.xm6.m0[cgs] @m.x1.x2.x1.x3.xm6.m0[csb] @m.x1.x2.x1.x3.xm6.m0[cgd]
save @m.x1.x2.x1.x3.xm14.m0[id] @m.x1.x2.x1.x3.xm14.m0[gm] @m.x1.x2.x1.x3.xm14.m0[gds]
+ @m.x1.x2.x1.x3.xm14.m0[cdb] @m.x1.x2.x1.x3.xm14.m0[cgs] @m.x1.x2.x1.x3.xm14.m0[csb] @m.x1.x2.x1.x3.xm14.m0[cgd]
save @m.x1.x2.x1.x7.x1.xm1.m0[id] @m.x1.x2.x1.x7.x1.xm1.m0[gm] @m.x1.x2.x1.x7.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x7.x1.xm1.m0[cdb] @m.x1.x2.x1.x7.x1.xm1.m0[cgs] @m.x1.x2.x1.x7.x1.xm1.m0[csb] @m.x1.x2.x1.x7.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x7.x1.xm2.m0[id] @m.x1.x2.x1.x7.x1.xm2.m0[gm] @m.x1.x2.x1.x7.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x7.x1.xm2.m0[cdb] @m.x1.x2.x1.x7.x1.xm2.m0[cgs] @m.x1.x2.x1.x7.x1.xm2.m0[csb] @m.x1.x2.x1.x7.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x7.xm1.m0[id] @m.x1.x2.x1.x7.xm1.m0[gm] @m.x1.x2.x1.x7.xm1.m0[gds]
+ @m.x1.x2.x1.x7.xm1.m0[cdb] @m.x1.x2.x1.x7.xm1.m0[cgs] @m.x1.x2.x1.x7.xm1.m0[csb] @m.x1.x2.x1.x7.xm1.m0[cgd]
save @m.x1.x2.x1.x8.x1.xm1.m0[id] @m.x1.x2.x1.x8.x1.xm1.m0[gm] @m.x1.x2.x1.x8.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x8.x1.xm1.m0[cdb] @m.x1.x2.x1.x8.x1.xm1.m0[cgs] @m.x1.x2.x1.x8.x1.xm1.m0[csb] @m.x1.x2.x1.x8.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x8.x1.xm2.m0[id] @m.x1.x2.x1.x8.x1.xm2.m0[gm] @m.x1.x2.x1.x8.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x8.x1.xm2.m0[cdb] @m.x1.x2.x1.x8.x1.xm2.m0[cgs] @m.x1.x2.x1.x8.x1.xm2.m0[csb] @m.x1.x2.x1.x8.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x8.xm1.m0[id] @m.x1.x2.x1.x8.xm1.m0[gm] @m.x1.x2.x1.x8.xm1.m0[gds]
+ @m.x1.x2.x1.x8.xm1.m0[cdb] @m.x1.x2.x1.x8.xm1.m0[cgs] @m.x1.x2.x1.x8.xm1.m0[csb] @m.x1.x2.x1.x8.xm1.m0[cgd]
save @m.x1.x2.x1.x9.x1.xm1.m0[id] @m.x1.x2.x1.x9.x1.xm1.m0[gm] @m.x1.x2.x1.x9.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x9.x1.xm1.m0[cdb] @m.x1.x2.x1.x9.x1.xm1.m0[cgs] @m.x1.x2.x1.x9.x1.xm1.m0[csb] @m.x1.x2.x1.x9.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x9.x1.xm2.m0[id] @m.x1.x2.x1.x9.x1.xm2.m0[gm] @m.x1.x2.x1.x9.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x9.x1.xm2.m0[cdb] @m.x1.x2.x1.x9.x1.xm2.m0[cgs] @m.x1.x2.x1.x9.x1.xm2.m0[csb] @m.x1.x2.x1.x9.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x9.xm1.m0[id] @m.x1.x2.x1.x9.xm1.m0[gm] @m.x1.x2.x1.x9.xm1.m0[gds]
+ @m.x1.x2.x1.x9.xm1.m0[cdb] @m.x1.x2.x1.x9.xm1.m0[cgs] @m.x1.x2.x1.x9.xm1.m0[csb] @m.x1.x2.x1.x9.xm1.m0[cgd]
save @m.x1.x2.x1.x10.x1.xm1.m0[id] @m.x1.x2.x1.x10.x1.xm1.m0[gm] @m.x1.x2.x1.x10.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x10.x1.xm1.m0[cdb] @m.x1.x2.x1.x10.x1.xm1.m0[cgs] @m.x1.x2.x1.x10.x1.xm1.m0[csb] @m.x1.x2.x1.x10.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x10.x1.xm2.m0[id] @m.x1.x2.x1.x10.x1.xm2.m0[gm] @m.x1.x2.x1.x10.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x10.x1.xm2.m0[cdb] @m.x1.x2.x1.x10.x1.xm2.m0[cgs] @m.x1.x2.x1.x10.x1.xm2.m0[csb] @m.x1.x2.x1.x10.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x10.xm1.m0[id] @m.x1.x2.x1.x10.xm1.m0[gm] @m.x1.x2.x1.x10.xm1.m0[gds]
+ @m.x1.x2.x1.x10.xm1.m0[cdb] @m.x1.x2.x1.x10.xm1.m0[cgs] @m.x1.x2.x1.x10.xm1.m0[csb] @m.x1.x2.x1.x10.xm1.m0[cgd]
save @m.x1.x2.x1.x11.x1.xm1.m0[id] @m.x1.x2.x1.x11.x1.xm1.m0[gm] @m.x1.x2.x1.x11.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x11.x1.xm1.m0[cdb] @m.x1.x2.x1.x11.x1.xm1.m0[cgs] @m.x1.x2.x1.x11.x1.xm1.m0[csb] @m.x1.x2.x1.x11.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x11.x1.xm2.m0[id] @m.x1.x2.x1.x11.x1.xm2.m0[gm] @m.x1.x2.x1.x11.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x11.x1.xm2.m0[cdb] @m.x1.x2.x1.x11.x1.xm2.m0[cgs] @m.x1.x2.x1.x11.x1.xm2.m0[csb] @m.x1.x2.x1.x11.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x11.xm1.m0[id] @m.x1.x2.x1.x11.xm1.m0[gm] @m.x1.x2.x1.x11.xm1.m0[gds]
+ @m.x1.x2.x1.x11.xm1.m0[cdb] @m.x1.x2.x1.x11.xm1.m0[cgs] @m.x1.x2.x1.x11.xm1.m0[csb] @m.x1.x2.x1.x11.xm1.m0[cgd]
save @m.x1.x2.x1.x12.x1.xm1.m0[id] @m.x1.x2.x1.x12.x1.xm1.m0[gm] @m.x1.x2.x1.x12.x1.xm1.m0[gds]
+ @m.x1.x2.x1.x12.x1.xm1.m0[cdb] @m.x1.x2.x1.x12.x1.xm1.m0[cgs] @m.x1.x2.x1.x12.x1.xm1.m0[csb] @m.x1.x2.x1.x12.x1.xm1.m0[cgd]
save @m.x1.x2.x1.x12.x1.xm2.m0[id] @m.x1.x2.x1.x12.x1.xm2.m0[gm] @m.x1.x2.x1.x12.x1.xm2.m0[gds]
+ @m.x1.x2.x1.x12.x1.xm2.m0[cdb] @m.x1.x2.x1.x12.x1.xm2.m0[cgs] @m.x1.x2.x1.x12.x1.xm2.m0[csb] @m.x1.x2.x1.x12.x1.xm2.m0[cgd]
save @m.x1.x2.x1.x12.xm1.m0[id] @m.x1.x2.x1.x12.xm1.m0[gm] @m.x1.x2.x1.x12.xm1.m0[gds]
+ @m.x1.x2.x1.x12.xm1.m0[cdb] @m.x1.x2.x1.x12.xm1.m0[cgs] @m.x1.x2.x1.x12.xm1.m0[csb] @m.x1.x2.x1.x12.xm1.m0[cgd]
save @m.x1.x2.x1.x6.m0[id] @m.x1.x2.x1.x6.m0[gm] @m.x1.x2.x1.x6.m0[gds] @m.x1.x2.x1.x6.m0[cdb]
+ @m.x1.x2.x1.x6.m0[cgs] @m.x1.x2.x1.x6.m0[csb] @m.x1.x2.x1.x6.m0[cgd]
save @m.x1.x2.xc1.m0[id] @m.x1.x2.xc1.m0[gm] @m.x1.x2.xc1.m0[gds] @m.x1.x2.xc1.m0[cdb]
+ @m.x1.x2.xc1.m0[cgs] @m.x1.x2.xc1.m0[csb] @m.x1.x2.xc1.m0[cgd]
save @m.x1.x2.xc2.m0[id] @m.x1.x2.xc2.m0[gm] @m.x1.x2.xc2.m0[gds] @m.x1.x2.xc2.m0[cdb]
+ @m.x1.x2.xc2.m0[cgs] @m.x1.x2.xc2.m0[csb] @m.x1.x2.xc2.m0[cgd]
save @m.x1.x2.x2.x1.xm1.m0[id] @m.x1.x2.x2.x1.xm1.m0[gm] @m.x1.x2.x2.x1.xm1.m0[gds]
+ @m.x1.x2.x2.x1.xm1.m0[cdb] @m.x1.x2.x2.x1.xm1.m0[cgs] @m.x1.x2.x2.x1.xm1.m0[csb] @m.x1.x2.x2.x1.xm1.m0[cgd]
save @m.x1.x2.x2.x2.xm1.m0[id] @m.x1.x2.x2.x2.xm1.m0[gm] @m.x1.x2.x2.x2.xm1.m0[gds]
+ @m.x1.x2.x2.x2.xm1.m0[cdb] @m.x1.x2.x2.x2.xm1.m0[cgs] @m.x1.x2.x2.x2.xm1.m0[csb] @m.x1.x2.x2.x2.xm1.m0[cgd]
save @m.x1.x2.x2.x3.xm1.m0[id] @m.x1.x2.x2.x3.xm1.m0[gm] @m.x1.x2.x2.x3.xm1.m0[gds]
+ @m.x1.x2.x2.x3.xm1.m0[cdb] @m.x1.x2.x2.x3.xm1.m0[cgs] @m.x1.x2.x2.x3.xm1.m0[csb] @m.x1.x2.x2.x3.xm1.m0[cgd]
save @m.x1.x2.x2.x4.xm1.m0[id] @m.x1.x2.x2.x4.xm1.m0[gm] @m.x1.x2.x2.x4.xm1.m0[gds]
+ @m.x1.x2.x2.x4.xm1.m0[cdb] @m.x1.x2.x2.x4.xm1.m0[cgs] @m.x1.x2.x2.x4.xm1.m0[csb] @m.x1.x2.x2.x4.xm1.m0[cgd]
save @m.x1.x2.x3.xm1.m0[id] @m.x1.x2.x3.xm1.m0[gm] @m.x1.x2.x3.xm1.m0[gds] @m.x1.x2.x3.xm1.m0[cdb]
+ @m.x1.x2.x3.xm1.m0[cgs] @m.x1.x2.x3.xm1.m0[csb] @m.x1.x2.x3.xm1.m0[cgd]
save @m.x1.x2.x3.xm2.m0[id] @m.x1.x2.x3.xm2.m0[gm] @m.x1.x2.x3.xm2.m0[gds] @m.x1.x2.x3.xm2.m0[cdb]
+ @m.x1.x2.x3.xm2.m0[cgs] @m.x1.x2.x3.xm2.m0[csb] @m.x1.x2.x3.xm2.m0[cgd]
save @m.x1.x2.x3.xm3.m0[id] @m.x1.x2.x3.xm3.m0[gm] @m.x1.x2.x3.xm3.m0[gds] @m.x1.x2.x3.xm3.m0[cdb]
+ @m.x1.x2.x3.xm3.m0[cgs] @m.x1.x2.x3.xm3.m0[csb] @m.x1.x2.x3.xm3.m0[cgd]
save @m.x1.x2.xc3.m0[id] @m.x1.x2.xc3.m0[gm] @m.x1.x2.xc3.m0[gds] @m.x1.x2.xc3.m0[cdb]
+ @m.x1.x2.xc3.m0[cgs] @m.x1.x2.xc3.m0[csb] @m.x1.x2.xc3.m0[cgd]
save @m.x1.x2.xc4.m0[id] @m.x1.x2.xc4.m0[gm] @m.x1.x2.xc4.m0[gds] @m.x1.x2.xc4.m0[cdb]
+ @m.x1.x2.xc4.m0[cgs] @m.x1.x2.xc4.m0[csb] @m.x1.x2.xc4.m0[cgd]
save @m.x1.x2.x4.x3.xm1.m0[id] @m.x1.x2.x4.x3.xm1.m0[gm] @m.x1.x2.x4.x3.xm1.m0[gds]
+ @m.x1.x2.x4.x3.xm1.m0[cdb] @m.x1.x2.x4.x3.xm1.m0[cgs] @m.x1.x2.x4.x3.xm1.m0[csb] @m.x1.x2.x4.x3.xm1.m0[cgd]
save @m.x1.x2.x4.x3.xm5.m0[id] @m.x1.x2.x4.x3.xm5.m0[gm] @m.x1.x2.x4.x3.xm5.m0[gds]
+ @m.x1.x2.x4.x3.xm5.m0[cdb] @m.x1.x2.x4.x3.xm5.m0[cgs] @m.x1.x2.x4.x3.xm5.m0[csb] @m.x1.x2.x4.x3.xm5.m0[cgd]
save @m.x1.x2.x4.x3.xm15.m0[id] @m.x1.x2.x4.x3.xm15.m0[gm] @m.x1.x2.x4.x3.xm15.m0[gds]
+ @m.x1.x2.x4.x3.xm15.m0[cdb] @m.x1.x2.x4.x3.xm15.m0[cgs] @m.x1.x2.x4.x3.xm15.m0[csb] @m.x1.x2.x4.x3.xm15.m0[cgd]
save @m.x1.x2.x4.x3.xm9.m0[id] @m.x1.x2.x4.x3.xm9.m0[gm] @m.x1.x2.x4.x3.xm9.m0[gds]
+ @m.x1.x2.x4.x3.xm9.m0[cdb] @m.x1.x2.x4.x3.xm9.m0[cgs] @m.x1.x2.x4.x3.xm9.m0[csb] @m.x1.x2.x4.x3.xm9.m0[cgd]
save @m.x1.x2.x4.x3.xm6.m0[id] @m.x1.x2.x4.x3.xm6.m0[gm] @m.x1.x2.x4.x3.xm6.m0[gds]
+ @m.x1.x2.x4.x3.xm6.m0[cdb] @m.x1.x2.x4.x3.xm6.m0[cgs] @m.x1.x2.x4.x3.xm6.m0[csb] @m.x1.x2.x4.x3.xm6.m0[cgd]
save @m.x1.x2.x4.x3.xm14.m0[id] @m.x1.x2.x4.x3.xm14.m0[gm] @m.x1.x2.x4.x3.xm14.m0[gds]
+ @m.x1.x2.x4.x3.xm14.m0[cdb] @m.x1.x2.x4.x3.xm14.m0[cgs] @m.x1.x2.x4.x3.xm14.m0[csb] @m.x1.x2.x4.x3.xm14.m0[cgd]
save @m.x1.x2.x4.x4.xm4.m0[id] @m.x1.x2.x4.x4.xm4.m0[gm] @m.x1.x2.x4.x4.xm4.m0[gds]
+ @m.x1.x2.x4.x4.xm4.m0[cdb] @m.x1.x2.x4.x4.xm4.m0[cgs] @m.x1.x2.x4.x4.xm4.m0[csb] @m.x1.x2.x4.x4.xm4.m0[cgd]
save @m.x1.x2.x4.x4.xm16.m0[id] @m.x1.x2.x4.x4.xm16.m0[gm] @m.x1.x2.x4.x4.xm16.m0[gds]
+ @m.x1.x2.x4.x4.xm16.m0[cdb] @m.x1.x2.x4.x4.xm16.m0[cgs] @m.x1.x2.x4.x4.xm16.m0[csb] @m.x1.x2.x4.x4.xm16.m0[cgd]
save @m.x1.x2.x4.x4.xm17.m0[id] @m.x1.x2.x4.x4.xm17.m0[gm] @m.x1.x2.x4.x4.xm17.m0[gds]
+ @m.x1.x2.x4.x4.xm17.m0[cdb] @m.x1.x2.x4.x4.xm17.m0[cgs] @m.x1.x2.x4.x4.xm17.m0[csb] @m.x1.x2.x4.x4.xm17.m0[cgd]
save @m.x1.x2.x4.x4.xm18.m0[id] @m.x1.x2.x4.x4.xm18.m0[gm] @m.x1.x2.x4.x4.xm18.m0[gds]
+ @m.x1.x2.x4.x4.xm18.m0[cdb] @m.x1.x2.x4.x4.xm18.m0[cgs] @m.x1.x2.x4.x4.xm18.m0[csb] @m.x1.x2.x4.x4.xm18.m0[cgd]
save @m.x1.x2.x4.x1.xm2.m0[id] @m.x1.x2.x4.x1.xm2.m0[gm] @m.x1.x2.x4.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x1.xm2.m0[cdb] @m.x1.x2.x4.x1.xm2.m0[cgs] @m.x1.x2.x4.x1.xm2.m0[csb] @m.x1.x2.x4.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x1.xm3.m0[id] @m.x1.x2.x4.x1.xm3.m0[gm] @m.x1.x2.x4.x1.xm3.m0[gds]
+ @m.x1.x2.x4.x1.xm3.m0[cdb] @m.x1.x2.x4.x1.xm3.m0[cgs] @m.x1.x2.x4.x1.xm3.m0[csb] @m.x1.x2.x4.x1.xm3.m0[cgd]
save @m.x1.x2.x4.x2.xm10.m0[id] @m.x1.x2.x4.x2.xm10.m0[gm] @m.x1.x2.x4.x2.xm10.m0[gds]
+ @m.x1.x2.x4.x2.xm10.m0[cdb] @m.x1.x2.x4.x2.xm10.m0[cgs] @m.x1.x2.x4.x2.xm10.m0[csb] @m.x1.x2.x4.x2.xm10.m0[cgd]
save @m.x1.x2.x4.x2.xm11.m0[id] @m.x1.x2.x4.x2.xm11.m0[gm] @m.x1.x2.x4.x2.xm11.m0[gds]
+ @m.x1.x2.x4.x2.xm11.m0[cdb] @m.x1.x2.x4.x2.xm11.m0[cgs] @m.x1.x2.x4.x2.xm11.m0[csb] @m.x1.x2.x4.x2.xm11.m0[cgd]
save @m.x1.x2.x4.x2.xm7.m0[id] @m.x1.x2.x4.x2.xm7.m0[gm] @m.x1.x2.x4.x2.xm7.m0[gds]
+ @m.x1.x2.x4.x2.xm7.m0[cdb] @m.x1.x2.x4.x2.xm7.m0[cgs] @m.x1.x2.x4.x2.xm7.m0[csb] @m.x1.x2.x4.x2.xm7.m0[cgd]
save @m.x1.x2.x4.x2.xm8.m0[id] @m.x1.x2.x4.x2.xm8.m0[gm] @m.x1.x2.x4.x2.xm8.m0[gds]
+ @m.x1.x2.x4.x2.xm8.m0[cdb] @m.x1.x2.x4.x2.xm8.m0[cgs] @m.x1.x2.x4.x2.xm8.m0[csb] @m.x1.x2.x4.x2.xm8.m0[cgd]
save @m.x1.x2.x4.x5.xm16.m0[id] @m.x1.x2.x4.x5.xm16.m0[gm] @m.x1.x2.x4.x5.xm16.m0[gds]
+ @m.x1.x2.x4.x5.xm16.m0[cdb] @m.x1.x2.x4.x5.xm16.m0[cgs] @m.x1.x2.x4.x5.xm16.m0[csb] @m.x1.x2.x4.x5.xm16.m0[cgd]
save @m.x1.x2.x4.x5.xm12.m0[id] @m.x1.x2.x4.x5.xm12.m0[gm] @m.x1.x2.x4.x5.xm12.m0[gds]
+ @m.x1.x2.x4.x5.xm12.m0[cdb] @m.x1.x2.x4.x5.xm12.m0[cgs] @m.x1.x2.x4.x5.xm12.m0[csb] @m.x1.x2.x4.x5.xm12.m0[cgd]
save @m.x1.x2.x4.x5.xm25.m0[id] @m.x1.x2.x4.x5.xm25.m0[gm] @m.x1.x2.x4.x5.xm25.m0[gds]
+ @m.x1.x2.x4.x5.xm25.m0[cdb] @m.x1.x2.x4.x5.xm25.m0[cgs] @m.x1.x2.x4.x5.xm25.m0[csb] @m.x1.x2.x4.x5.xm25.m0[cgd]
save @m.x1.x2.x4.x5.xm1.m0[id] @m.x1.x2.x4.x5.xm1.m0[gm] @m.x1.x2.x4.x5.xm1.m0[gds]
+ @m.x1.x2.x4.x5.xm1.m0[cdb] @m.x1.x2.x4.x5.xm1.m0[cgs] @m.x1.x2.x4.x5.xm1.m0[csb] @m.x1.x2.x4.x5.xm1.m0[cgd]
save @m.x1.x2.x4.x7.x1.xm1.m0[id] @m.x1.x2.x4.x7.x1.xm1.m0[gm] @m.x1.x2.x4.x7.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x7.x1.xm1.m0[cdb] @m.x1.x2.x4.x7.x1.xm1.m0[cgs] @m.x1.x2.x4.x7.x1.xm1.m0[csb] @m.x1.x2.x4.x7.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x7.x1.xm2.m0[id] @m.x1.x2.x4.x7.x1.xm2.m0[gm] @m.x1.x2.x4.x7.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x7.x1.xm2.m0[cdb] @m.x1.x2.x4.x7.x1.xm2.m0[cgs] @m.x1.x2.x4.x7.x1.xm2.m0[csb] @m.x1.x2.x4.x7.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x7.xm1.m0[id] @m.x1.x2.x4.x7.xm1.m0[gm] @m.x1.x2.x4.x7.xm1.m0[gds]
+ @m.x1.x2.x4.x7.xm1.m0[cdb] @m.x1.x2.x4.x7.xm1.m0[cgs] @m.x1.x2.x4.x7.xm1.m0[csb] @m.x1.x2.x4.x7.xm1.m0[cgd]
save @m.x1.x2.x4.x8.x1.xm1.m0[id] @m.x1.x2.x4.x8.x1.xm1.m0[gm] @m.x1.x2.x4.x8.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x8.x1.xm1.m0[cdb] @m.x1.x2.x4.x8.x1.xm1.m0[cgs] @m.x1.x2.x4.x8.x1.xm1.m0[csb] @m.x1.x2.x4.x8.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x8.x1.xm2.m0[id] @m.x1.x2.x4.x8.x1.xm2.m0[gm] @m.x1.x2.x4.x8.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x8.x1.xm2.m0[cdb] @m.x1.x2.x4.x8.x1.xm2.m0[cgs] @m.x1.x2.x4.x8.x1.xm2.m0[csb] @m.x1.x2.x4.x8.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x8.xm1.m0[id] @m.x1.x2.x4.x8.xm1.m0[gm] @m.x1.x2.x4.x8.xm1.m0[gds]
+ @m.x1.x2.x4.x8.xm1.m0[cdb] @m.x1.x2.x4.x8.xm1.m0[cgs] @m.x1.x2.x4.x8.xm1.m0[csb] @m.x1.x2.x4.x8.xm1.m0[cgd]
save @m.x1.x2.x4.x9.x1.xm1.m0[id] @m.x1.x2.x4.x9.x1.xm1.m0[gm] @m.x1.x2.x4.x9.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x9.x1.xm1.m0[cdb] @m.x1.x2.x4.x9.x1.xm1.m0[cgs] @m.x1.x2.x4.x9.x1.xm1.m0[csb] @m.x1.x2.x4.x9.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x9.x1.xm2.m0[id] @m.x1.x2.x4.x9.x1.xm2.m0[gm] @m.x1.x2.x4.x9.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x9.x1.xm2.m0[cdb] @m.x1.x2.x4.x9.x1.xm2.m0[cgs] @m.x1.x2.x4.x9.x1.xm2.m0[csb] @m.x1.x2.x4.x9.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x9.xm1.m0[id] @m.x1.x2.x4.x9.xm1.m0[gm] @m.x1.x2.x4.x9.xm1.m0[gds]
+ @m.x1.x2.x4.x9.xm1.m0[cdb] @m.x1.x2.x4.x9.xm1.m0[cgs] @m.x1.x2.x4.x9.xm1.m0[csb] @m.x1.x2.x4.x9.xm1.m0[cgd]
save @m.x1.x2.x4.x10.x1.xm1.m0[id] @m.x1.x2.x4.x10.x1.xm1.m0[gm] @m.x1.x2.x4.x10.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x10.x1.xm1.m0[cdb] @m.x1.x2.x4.x10.x1.xm1.m0[cgs] @m.x1.x2.x4.x10.x1.xm1.m0[csb] @m.x1.x2.x4.x10.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x10.x1.xm2.m0[id] @m.x1.x2.x4.x10.x1.xm2.m0[gm] @m.x1.x2.x4.x10.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x10.x1.xm2.m0[cdb] @m.x1.x2.x4.x10.x1.xm2.m0[cgs] @m.x1.x2.x4.x10.x1.xm2.m0[csb] @m.x1.x2.x4.x10.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x10.xm1.m0[id] @m.x1.x2.x4.x10.xm1.m0[gm] @m.x1.x2.x4.x10.xm1.m0[gds]
+ @m.x1.x2.x4.x10.xm1.m0[cdb] @m.x1.x2.x4.x10.xm1.m0[cgs] @m.x1.x2.x4.x10.xm1.m0[csb] @m.x1.x2.x4.x10.xm1.m0[cgd]
save @m.x1.x2.x4.x11.x1.xm1.m0[id] @m.x1.x2.x4.x11.x1.xm1.m0[gm] @m.x1.x2.x4.x11.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x11.x1.xm1.m0[cdb] @m.x1.x2.x4.x11.x1.xm1.m0[cgs] @m.x1.x2.x4.x11.x1.xm1.m0[csb] @m.x1.x2.x4.x11.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x11.x1.xm2.m0[id] @m.x1.x2.x4.x11.x1.xm2.m0[gm] @m.x1.x2.x4.x11.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x11.x1.xm2.m0[cdb] @m.x1.x2.x4.x11.x1.xm2.m0[cgs] @m.x1.x2.x4.x11.x1.xm2.m0[csb] @m.x1.x2.x4.x11.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x11.xm1.m0[id] @m.x1.x2.x4.x11.xm1.m0[gm] @m.x1.x2.x4.x11.xm1.m0[gds]
+ @m.x1.x2.x4.x11.xm1.m0[cdb] @m.x1.x2.x4.x11.xm1.m0[cgs] @m.x1.x2.x4.x11.xm1.m0[csb] @m.x1.x2.x4.x11.xm1.m0[cgd]
save @m.x1.x2.x4.x12.x1.xm1.m0[id] @m.x1.x2.x4.x12.x1.xm1.m0[gm] @m.x1.x2.x4.x12.x1.xm1.m0[gds]
+ @m.x1.x2.x4.x12.x1.xm1.m0[cdb] @m.x1.x2.x4.x12.x1.xm1.m0[cgs] @m.x1.x2.x4.x12.x1.xm1.m0[csb] @m.x1.x2.x4.x12.x1.xm1.m0[cgd]
save @m.x1.x2.x4.x12.x1.xm2.m0[id] @m.x1.x2.x4.x12.x1.xm2.m0[gm] @m.x1.x2.x4.x12.x1.xm2.m0[gds]
+ @m.x1.x2.x4.x12.x1.xm2.m0[cdb] @m.x1.x2.x4.x12.x1.xm2.m0[cgs] @m.x1.x2.x4.x12.x1.xm2.m0[csb] @m.x1.x2.x4.x12.x1.xm2.m0[cgd]
save @m.x1.x2.x4.x12.xm1.m0[id] @m.x1.x2.x4.x12.xm1.m0[gm] @m.x1.x2.x4.x12.xm1.m0[gds]
+ @m.x1.x2.x4.x12.xm1.m0[cdb] @m.x1.x2.x4.x12.xm1.m0[cgs] @m.x1.x2.x4.x12.xm1.m0[csb] @m.x1.x2.x4.x12.xm1.m0[cgd]
save @m.x1.x2.x4.x6.m0[id] @m.x1.x2.x4.x6.m0[gm] @m.x1.x2.x4.x6.m0[gds] @m.x1.x2.x4.x6.m0[cdb]
+ @m.x1.x2.x4.x6.m0[cgs] @m.x1.x2.x4.x6.m0[csb] @m.x1.x2.x4.x6.m0[cgd]
save @m.x1.x3.x1.xm1.m0[id] @m.x1.x3.x1.xm1.m0[gm] @m.x1.x3.x1.xm1.m0[gds] @m.x1.x3.x1.xm1.m0[cdb]
+ @m.x1.x3.x1.xm1.m0[cgs] @m.x1.x3.x1.xm1.m0[csb] @m.x1.x3.x1.xm1.m0[cgd]
save @m.x1.x3.x2.xm1.m0[id] @m.x1.x3.x2.xm1.m0[gm] @m.x1.x3.x2.xm1.m0[gds] @m.x1.x3.x2.xm1.m0[cdb]
+ @m.x1.x3.x2.xm1.m0[cgs] @m.x1.x3.x2.xm1.m0[csb] @m.x1.x3.x2.xm1.m0[cgd]
save @m.x1.x3.x3.xm1.m0[id] @m.x1.x3.x3.xm1.m0[gm] @m.x1.x3.x3.xm1.m0[gds] @m.x1.x3.x3.xm1.m0[cdb]
+ @m.x1.x3.x3.xm1.m0[cgs] @m.x1.x3.x3.xm1.m0[csb] @m.x1.x3.x3.xm1.m0[cgd]
save @m.x1.x3.x4.xm1.m0[id] @m.x1.x3.x4.xm1.m0[gm] @m.x1.x3.x4.xm1.m0[gds] @m.x1.x3.x4.xm1.m0[cdb]
+ @m.x1.x3.x4.xm1.m0[cgs] @m.x1.x3.x4.xm1.m0[csb] @m.x1.x3.x4.xm1.m0[cgd]
save @m.x1.x4.x1.xm1.m0[id] @m.x1.x4.x1.xm1.m0[gm] @m.x1.x4.x1.xm1.m0[gds] @m.x1.x4.x1.xm1.m0[cdb]
+ @m.x1.x4.x1.xm1.m0[cgs] @m.x1.x4.x1.xm1.m0[csb] @m.x1.x4.x1.xm1.m0[cgd]
save @m.x1.x4.x2.xm1.m0[id] @m.x1.x4.x2.xm1.m0[gm] @m.x1.x4.x2.xm1.m0[gds] @m.x1.x4.x2.xm1.m0[cdb]
+ @m.x1.x4.x2.xm1.m0[cgs] @m.x1.x4.x2.xm1.m0[csb] @m.x1.x4.x2.xm1.m0[cgd]
save @m.x1.x4.x3.xm1.m0[id] @m.x1.x4.x3.xm1.m0[gm] @m.x1.x4.x3.xm1.m0[gds] @m.x1.x4.x3.xm1.m0[cdb]
+ @m.x1.x4.x3.xm1.m0[cgs] @m.x1.x4.x3.xm1.m0[csb] @m.x1.x4.x3.xm1.m0[cgd]
save @m.x1.x4.x4.xm1.m0[id] @m.x1.x4.x4.xm1.m0[gm] @m.x1.x4.x4.xm1.m0[gds] @m.x1.x4.x4.xm1.m0[cdb]
+ @m.x1.x4.x4.xm1.m0[cgs] @m.x1.x4.x4.xm1.m0[csb] @m.x1.x4.x4.xm1.m0[cgd]
save @m.x1.xc3.m0[id] @m.x1.xc3.m0[gm] @m.x1.xc3.m0[gds] @m.x1.xc3.m0[cdb] @m.x1.xc3.m0[cgs]
+ @m.x1.xc3.m0[csb] @m.x1.xc3.m0[cgd]
save @m.x1.xc1.m0[id] @m.x1.xc1.m0[gm] @m.x1.xc1.m0[gds] @m.x1.xc1.m0[cdb] @m.x1.xc1.m0[cgs]
+ @m.x1.xc1.m0[csb] @m.x1.xc1.m0[cgd]
save @m.x1.x5.x1.xm1.m0[id] @m.x1.x5.x1.xm1.m0[gm] @m.x1.x5.x1.xm1.m0[gds] @m.x1.x5.x1.xm1.m0[cdb]
+ @m.x1.x5.x1.xm1.m0[cgs] @m.x1.x5.x1.xm1.m0[csb] @m.x1.x5.x1.xm1.m0[cgd]
save @m.x1.x5.x2.xm1.m0[id] @m.x1.x5.x2.xm1.m0[gm] @m.x1.x5.x2.xm1.m0[gds] @m.x1.x5.x2.xm1.m0[cdb]
+ @m.x1.x5.x2.xm1.m0[cgs] @m.x1.x5.x2.xm1.m0[csb] @m.x1.x5.x2.xm1.m0[cgd]
save @m.x1.x5.x3.xm1.m0[id] @m.x1.x5.x3.xm1.m0[gm] @m.x1.x5.x3.xm1.m0[gds] @m.x1.x5.x3.xm1.m0[cdb]
+ @m.x1.x5.x3.xm1.m0[cgs] @m.x1.x5.x3.xm1.m0[csb] @m.x1.x5.x3.xm1.m0[cgd]
save @m.x1.x5.x4.xm1.m0[id] @m.x1.x5.x4.xm1.m0[gm] @m.x1.x5.x4.xm1.m0[gds] @m.x1.x5.x4.xm1.m0[cdb]
+ @m.x1.x5.x4.xm1.m0[cgs] @m.x1.x5.x4.xm1.m0[csb] @m.x1.x5.x4.xm1.m0[cgd]
save @m.x1.x6.xm1.m0[id] @m.x1.x6.xm1.m0[gm] @m.x1.x6.xm1.m0[gds] @m.x1.x6.xm1.m0[cdb]
+ @m.x1.x6.xm1.m0[cgs] @m.x1.x6.xm1.m0[csb] @m.x1.x6.xm1.m0[cgd]
save @m.x1.x6.xm2.m0[id] @m.x1.x6.xm2.m0[gm] @m.x1.x6.xm2.m0[gds] @m.x1.x6.xm2.m0[cdb]
+ @m.x1.x6.xm2.m0[cgs] @m.x1.x6.xm2.m0[csb] @m.x1.x6.xm2.m0[cgd]
save @m.x1.x6.xm3.m0[id] @m.x1.x6.xm3.m0[gm] @m.x1.x6.xm3.m0[gds] @m.x1.x6.xm3.m0[cdb]
+ @m.x1.x6.xm3.m0[cgs] @m.x1.x6.xm3.m0[csb] @m.x1.x6.xm3.m0[cgd]
save @m.x1.xc2.m0[id] @m.x1.xc2.m0[gm] @m.x1.xc2.m0[gds] @m.x1.xc2.m0[cdb] @m.x1.xc2.m0[cgs]
+ @m.x1.xc2.m0[csb] @m.x1.xc2.m0[cgd]
save @m.x1.xc4.m0[id] @m.x1.xc4.m0[gm] @m.x1.xc4.m0[gds] @m.x1.xc4.m0[cdb] @m.x1.xc4.m0[cgs]
+ @m.x1.xc4.m0[csb] @m.x1.xc4.m0[cgd]
save @m.x1.xc5.m0[id] @m.x1.xc5.m0[gm] @m.x1.xc5.m0[gds] @m.x1.xc5.m0[cdb] @m.x1.xc5.m0[cgs]
+ @m.x1.xc5.m0[csb] @m.x1.xc5.m0[cgd]
save @m.x1.xc6.m0[id] @m.x1.xc6.m0[gm] @m.x1.xc6.m0[gds] @m.x1.xc6.m0[cdb] @m.x1.xc6.m0[cgs]
+ @m.x1.xc6.m0[csb] @m.x1.xc6.m0[cgd]
save @m.x1.xc7.m0[id] @m.x1.xc7.m0[gm] @m.x1.xc7.m0[gds] @m.x1.xc7.m0[cdb] @m.x1.xc7.m0[cgs]
+ @m.x1.xc7.m0[csb] @m.x1.xc7.m0[cgd]
save @m.x1.x7.xm1.m0[id] @m.x1.x7.xm1.m0[gm] @m.x1.x7.xm1.m0[gds] @m.x1.x7.xm1.m0[cdb]
+ @m.x1.x7.xm1.m0[cgs] @m.x1.x7.xm1.m0[csb] @m.x1.x7.xm1.m0[cgd]
save @m.x1.x7.xm2.m0[id] @m.x1.x7.xm2.m0[gm] @m.x1.x7.xm2.m0[gds] @m.x1.x7.xm2.m0[cdb]
+ @m.x1.x7.xm2.m0[cgs] @m.x1.x7.xm2.m0[csb] @m.x1.x7.xm2.m0[cgd]
save @m.x1.x8.xm1.m0[id] @m.x1.x8.xm1.m0[gm] @m.x1.x8.xm1.m0[gds] @m.x1.x8.xm1.m0[cdb]
+ @m.x1.x8.xm1.m0[cgs] @m.x1.x8.xm1.m0[csb] @m.x1.x8.xm1.m0[cgd]
save @m.x1.x8.xm2.m0[id] @m.x1.x8.xm2.m0[gm] @m.x1.x8.xm2.m0[gds] @m.x1.x8.xm2.m0[cdb]
+ @m.x1.x8.xm2.m0[cgs] @m.x1.x8.xm2.m0[csb] @m.x1.x8.xm2.m0[cgd]
save @m.x1.x9.xm1.m0[id] @m.x1.x9.xm1.m0[gm] @m.x1.x9.xm1.m0[gds] @m.x1.x9.xm1.m0[cdb]
+ @m.x1.x9.xm1.m0[cgs] @m.x1.x9.xm1.m0[csb] @m.x1.x9.xm1.m0[cgd]
save @m.x1.x9.xm2.m0[id] @m.x1.x9.xm2.m0[gm] @m.x1.x9.xm2.m0[gds] @m.x1.x9.xm2.m0[cdb]
+ @m.x1.x9.xm2.m0[cgs] @m.x1.x9.xm2.m0[csb] @m.x1.x9.xm2.m0[cgd]
save @m.x1.x10.xm1.m0[id] @m.x1.x10.xm1.m0[gm] @m.x1.x10.xm1.m0[gds] @m.x1.x10.xm1.m0[cdb]
+ @m.x1.x10.xm1.m0[cgs] @m.x1.x10.xm1.m0[csb] @m.x1.x10.xm1.m0[cgd]
save @m.x1.x10.xm2.m0[id] @m.x1.x10.xm2.m0[gm] @m.x1.x10.xm2.m0[gds] @m.x1.x10.xm2.m0[cdb]
+ @m.x1.x10.xm2.m0[cgs] @m.x1.x10.xm2.m0[csb] @m.x1.x10.xm2.m0[cgd]
save @m.x1.x11.m0[id] @m.x1.x11.m0[gm] @m.x1.x11.m0[gds] @m.x1.x11.m0[cdb] @m.x1.x11.m0[cgs]
+ @m.x1.x11.m0[csb] @m.x1.x11.m0[cgd]
save @m.x1.x12.m0[id] @m.x1.x12.m0[gm] @m.x1.x12.m0[gds] @m.x1.x12.m0[cdb] @m.x1.x12.m0[cgs]
+ @m.x1.x12.m0[csb] @m.x1.x12.m0[cgd]
save @m.x1.x13.m0[id] @m.x1.x13.m0[gm] @m.x1.x13.m0[gds] @m.x1.x13.m0[cdb] @m.x1.x13.m0[cgs]
+ @m.x1.x13.m0[csb] @m.x1.x13.m0[cgd]
save @m.x1.x14.m0[id] @m.x1.x14.m0[gm] @m.x1.x14.m0[gds] @m.x1.x14.m0[cdb] @m.x1.x14.m0[cgs]
+ @m.x1.x14.m0[csb] @m.x1.x14.m0[cgd]
save @m.x1.xc8.m0[id] @m.x1.xc8.m0[gm] @m.x1.xc8.m0[gds] @m.x1.xc8.m0[cdb] @m.x1.xc8.m0[cgs]
+ @m.x1.xc8.m0[csb] @m.x1.xc8.m0[cgd]
save @m.x1.xc9.m0[id] @m.x1.xc9.m0[gm] @m.x1.xc9.m0[gds] @m.x1.xc9.m0[cdb] @m.x1.xc9.m0[cgs]
+ @m.x1.xc9.m0[csb] @m.x1.xc9.m0[cgd]
save @m.x1.xc10.m0[id] @m.x1.xc10.m0[gm] @m.x1.xc10.m0[gds] @m.x1.xc10.m0[cdb] @m.x1.xc10.m0[cgs]
+ @m.x1.xc10.m0[csb] @m.x1.xc10.m0[cgd]
save @m.x1.xc11.m0[id] @m.x1.xc11.m0[gm] @m.x1.xc11.m0[gds] @m.x1.xc11.m0[cdb] @m.x1.xc11.m0[cgs]
+ @m.x1.xc11.m0[csb] @m.x1.xc11.m0[cgd]
save @m.x1.xc12.m0[id] @m.x1.xc12.m0[gm] @m.x1.xc12.m0[gds] @m.x1.xc12.m0[cdb] @m.x1.xc12.m0[cgs]
+ @m.x1.xc12.m0[csb] @m.x1.xc12.m0[cgd]
save @m.x1.x15.xm1.m0[id] @m.x1.x15.xm1.m0[gm] @m.x1.x15.xm1.m0[gds] @m.x1.x15.xm1.m0[cdb]
+ @m.x1.x15.xm1.m0[cgs] @m.x1.x15.xm1.m0[csb] @m.x1.x15.xm1.m0[cgd]
save @m.x1.x15.xm2.m0[id] @m.x1.x15.xm2.m0[gm] @m.x1.x15.xm2.m0[gds] @m.x1.x15.xm2.m0[cdb]
+ @m.x1.x15.xm2.m0[cgs] @m.x1.x15.xm2.m0[csb] @m.x1.x15.xm2.m0[cgd]
save @m.x1.x16.xm1.m0[id] @m.x1.x16.xm1.m0[gm] @m.x1.x16.xm1.m0[gds] @m.x1.x16.xm1.m0[cdb]
+ @m.x1.x16.xm1.m0[cgs] @m.x1.x16.xm1.m0[csb] @m.x1.x16.xm1.m0[cgd]
save @m.x1.x16.xm2.m0[id] @m.x1.x16.xm2.m0[gm] @m.x1.x16.xm2.m0[gds] @m.x1.x16.xm2.m0[cdb]
+ @m.x1.x16.xm2.m0[cgs] @m.x1.x16.xm2.m0[csb] @m.x1.x16.xm2.m0[cgd]
save @m.x1.x17.xm1.m0[id] @m.x1.x17.xm1.m0[gm] @m.x1.x17.xm1.m0[gds] @m.x1.x17.xm1.m0[cdb]
+ @m.x1.x17.xm1.m0[cgs] @m.x1.x17.xm1.m0[csb] @m.x1.x17.xm1.m0[cgd]
save @m.x1.x17.xm2.m0[id] @m.x1.x17.xm2.m0[gm] @m.x1.x17.xm2.m0[gds] @m.x1.x17.xm2.m0[cdb]
+ @m.x1.x17.xm2.m0[cgs] @m.x1.x17.xm2.m0[csb] @m.x1.x17.xm2.m0[cgd]
save @m.x1.x18.xm1.m0[id] @m.x1.x18.xm1.m0[gm] @m.x1.x18.xm1.m0[gds] @m.x1.x18.xm1.m0[cdb]
+ @m.x1.x18.xm1.m0[cgs] @m.x1.x18.xm1.m0[csb] @m.x1.x18.xm1.m0[cgd]
save @m.x1.x18.xm2.m0[id] @m.x1.x18.xm2.m0[gm] @m.x1.x18.xm2.m0[gds] @m.x1.x18.xm2.m0[cdb]
+ @m.x1.x18.xm2.m0[cgs] @m.x1.x18.xm2.m0[csb] @m.x1.x18.xm2.m0[cgd]
op
write op.raw all
tran 1n 200u
.endc


**** end user architecture code
**.ends
.end
