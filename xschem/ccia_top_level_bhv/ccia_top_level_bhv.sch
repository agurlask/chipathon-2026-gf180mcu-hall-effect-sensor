v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Spinning Clock Inputs} 0 -810 0 0 0.4 0.4 {}
T {sp(x): active phase marker (all phi/o derived from sp(x))
phi(x): sensor bias switch control
o(x): output/ccia chopping switch control (non-overlapping)
} 0 -780 0 0 0.2 0.2 {}
T {Supply/Reference Inputs} 0 -550 0 0 0.4 0.4 {}
T {Instrumentation Amplifier I/O} 0 -320 0 0 0.4 0.4 {}
C {iopin.sym} 0 -700 0 0 {name=p13 lab=o1}
C {iopin.sym} 0 -660 0 0 {name=p14 lab=o2}
C {iopin.sym} 0 -620 0 0 {name=p15 lab=o3}
C {iopin.sym} 0 -580 0 0 {name=p16 lab=o4}
C {iopin.sym} 0 -490 0 0 {name=p20 lab=vdd}
C {iopin.sym} 0 -450 0 0 {name=p21 lab=vss}
C {iopin.sym} 0 -270 0 0 {name=p18 lab=ia_vin_p}
C {iopin.sym} 0 -230 0 0 {name=p19 lab=ia_vin_n}
C {iopin.sym} 0 -410 0 0 {name=p1 lab=vcm}
C {iopin.sym} 0 -370 0 0 {name=p2 lab=ia_ibias}
C {iopin.sym} 0 -190 0 0 {name=p3 lab=ia_vout_p}
C {iopin.sym} 0 -150 0 0 {name=p4 lab=ia_vout_n}
C {title.sym} 160 -40 0 0 {name=l1 author="alang"}
