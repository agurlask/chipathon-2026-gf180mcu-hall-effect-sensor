v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Timing Reference} 0 -500 0 0 0.4 0.4 {}
T {Spinning Clock Outputs} 0 -410 0 0 0.4 0.4 {}
T {sp(x): active phase marker (all phi/o derived from sp(x))
phi(x): sensor bias switch control
o(x): output/ccia chopping switch control (non-overlapping)
} 0 -380 0 0 0.2 0.2 {}
T {Supply Input} 0 -640 0 0 0.4 0.4 {}
T {Reset Input (active low)} 0 -170 0 0 0.4 0.4 {}
C {iopin.sym} 0 -450 0 0 {name=p4 lab=clk}
C {iopin.sym} 0 -320 0 0 {name=p5 lab=phi1}
C {iopin.sym} 0 -280 0 0 {name=p6 lab=phi2}
C {iopin.sym} 0 -240 0 0 {name=p7 lab=phi3}
C {iopin.sym} 0 -200 0 0 {name=p8 lab=phi4}
C {iopin.sym} 120 -320 0 0 {name=p9 lab=sp1}
C {iopin.sym} 120 -280 0 0 {name=p10 lab=sp2}
C {iopin.sym} 120 -240 0 0 {name=p11 lab=sp3}
C {iopin.sym} 120 -200 0 0 {name=p12 lab=sp4}
C {iopin.sym} 240 -320 0 0 {name=p13 lab=o1}
C {iopin.sym} 240 -280 0 0 {name=p14 lab=o2}
C {iopin.sym} 240 -240 0 0 {name=p15 lab=o3}
C {iopin.sym} 240 -200 0 0 {name=p16 lab=o4}
C {iopin.sym} 0 -590 0 0 {name=p20 lab=vdd}
C {iopin.sym} 0 -550 0 0 {name=p21 lab=vss}
C {iopin.sym} 0 -120 0 0 {name=p1 lab=reset_n}
C {title.sym} 160 -40 0 0 {name=l1 author="alang"}
