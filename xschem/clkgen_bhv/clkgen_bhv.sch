v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Timing Reference} 0 -380 0 0 0.4 0.4 {}
T {Spinning Clock Outputs} 0 -290 0 0 0.4 0.4 {}
T {sp(x): active phase marker (all phi/o derived from sp(x))
phi(x): sensor bias switch control
o(x): output/ccia chopping switch control (non-overlapping)
} 0 -260 0 0 0.2 0.2 {}
T {Supply Input} 0 -520 0 0 0.4 0.4 {}
C {iopin.sym} 0 -330 0 0 {name=p4 lab=clk}
C {iopin.sym} 0 -200 0 0 {name=p5 lab=phi1}
C {iopin.sym} 0 -160 0 0 {name=p6 lab=phi2}
C {iopin.sym} 0 -120 0 0 {name=p7 lab=phi3}
C {iopin.sym} 0 -80 0 0 {name=p8 lab=phi4}
C {iopin.sym} 120 -200 0 0 {name=p9 lab=sp1}
C {iopin.sym} 120 -160 0 0 {name=p10 lab=sp2}
C {iopin.sym} 120 -120 0 0 {name=p11 lab=sp3}
C {iopin.sym} 120 -80 0 0 {name=p12 lab=sp4}
C {iopin.sym} 240 -200 0 0 {name=p13 lab=o1}
C {iopin.sym} 240 -160 0 0 {name=p14 lab=o2}
C {iopin.sym} 240 -120 0 0 {name=p15 lab=o3}
C {iopin.sym} 240 -80 0 0 {name=p16 lab=o4}
C {iopin.sym} 0 -470 0 0 {name=p20 lab=vdd}
C {iopin.sym} 0 -430 0 0 {name=p21 lab=vss}
