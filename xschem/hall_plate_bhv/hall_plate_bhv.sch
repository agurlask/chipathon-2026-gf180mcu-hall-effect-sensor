v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 0 -160 0 0 {name=p1 lab=sens_bn}
C {iopin.sym} 0 -200 0 0 {name=p2 lab=sens_an}
C {iopin.sym} 0 -240 0 0 {name=p3 lab=sens_bp}
C {iopin.sym} 0 -280 0 0 {name=p4 lab=sens_ap}
C {title.sym} 160 -40 0 0 {name=l1 author="alang"}
